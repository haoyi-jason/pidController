# IAR project pidController.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM361 AnalogDevices ADuCM361
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ; include; modbus\; ..\aduclibs\; ..\aduclibs\common; ..\aduclibs\include; $TOOLKIT_DIR$\inc\analogdevices\; $TOOLKIT_DIR$\cmsis\include; $FMB_DIR$\include; $FMB_DIR$\rtu
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: pidController.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group freemodbus
    $FMB_DIR$/: mb.c
  group freemodbus/functions
    $FMB_DIR$/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group freemodbus/port
    modbus/: mbRegs.c portevent.c portother.c portserial.c porttimer.c
  group freemodbus/rtu
    $FMB_DIR$/rtu/: mbcrc.c mbrtu.c
  group libs
    ../aducLibs/common/: AdcLib.c ClkLib.c DacLib.c DioLib.c DmaLib.c dvectrs.c FeeLib.c GptLib.c I2cLib.c IexcLib.c IntLib.c PwmLib.c PwrLib.c RstLib.c SpiLib.c UrtLib.c WdtLib.c WutLib.c
    ../aducLibs/common/IAR/: startup_ADuCM360.s
  group user
    source/: aducm360_isr.c eeParams.c halAducm360.c keypad.c modOperation.c param.c pid.c pidUser.c sensorif.c sysState.c userif.c
    include/: config.h
